# IAR project Combine.ewp, settings and files
configuration Combine (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; xUSER_DEBUG
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../BUTTON; ../CAN; ../EEPROM; ../INPUT; ../J1939; ../LCD; ../OUTPUT; ../SOUND; ../SYSTEM; ../TW9990; ../VC1W; ../WATCHDOG; ../SPI; ../I2C; ../USART; ../ADC; ../TIMER; ../RPM1
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Combine.bin
  ILINK.IlinkOutputFile: Combine.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../RPM1/: RPM.c RPM.h
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../: RPM1
  group Application/User/ADC
    ../ADC/: adc.c adc.h
  group Application/User/BUTTON
    ../BUTTON/: button.c button.h
  group Application/User/CAN
    ../CAN/: can.c can.h
  group Application/User/Core
    ../Core/Inc/: defines.h kiwonHardware.h main.h stm32f4xx_hal_conf.h
    ../Core/Src/: main.c
  group Application/User/EEPROM
    ../EEPROM/: AT93C56.C AT93C56.H
  group Application/User/I2C
    ../I2C/: i2c.c i2c.h
  group Application/User/INPUT
    ../INPUT/: input.c input.h
  group Application/User/J1939
    ../J1939/: J1939.c J1939.h pcode.c pcode.h
  group Application/User/LCD
    ../LCD/: dwt_stm32_delay.c dwt_stm32_delay.h Yvc1_HAL.c Yvc1_HAL.h
  group Application/User/OUTPUT
    ../OUTPUT/: output.c output.h
  group Application/User/SOUND
    ../SOUND/: sound.c sound.h
  group Application/User/SPI
    ../SPI/: spi.c spi.h
  group Application/User/SYSTEM
    ../SYSTEM/: system.c system.h
  group Application/User/TIMER
    ../TIMER/: timer.c timer.h
  group Application/User/TW9990
    ../TW9990/: tw9990.C tw9990.H
  group Application/User/USART
    ../USART/: usart.c usart.h
  group Application/User/VC1W
    ../VC1W/: HD800G48070MT_VC1W.h layoutData.c layoutData.h mapData.h sequenceData.c soundData.c YSeq.c YSeq.h YSeqConfig.h Yvc1.h Yvc1Ddrv.c Yvc1Ddrv.h Yvc1Fontctrl.c Yvc1Fontctrl.h Yvc1Lyr.c Yvc1Lyr.h Yvc1Pmem.c Yvc1Pmem.h Yvc1Vin.c Yvc1Vin.h Yvc1Wrp.c Yvc1Wrp.h Yvc643.h YvcConfig.h
  group Application/User/WATCHDOG
    ../WATCHDOG/: watchdog.c watchdog.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
